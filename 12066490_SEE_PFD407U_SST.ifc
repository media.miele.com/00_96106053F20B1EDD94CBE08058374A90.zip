Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2022-10-19T11:34:06
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 19 11:34:06 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\7dc9f386-7a25-4c8a-ad6a-3839b89f9acf\65a6fedf-f7ff-4615-a0a3-28f9c4366fe4\ifc * Database version: 5507 * Database creation date: Wed Oct 19 11:34:05 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 19 11:34:05 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 19 11:34:05 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12066490_SEE_PFD407U_SST:61040730_SEE_12066490_PFD407U_SST, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_BuildingElementProxyCommon - Reference: 61040730_SEE_12066490_PFD407U_SST
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 61040730_SEE_12066490_PFD407U_SST
Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_Alusilver, z_Miele_Design_Glass Black, z_Miele_Design_GRGR, z_Miele_Connection_Water_IN, z_Miele_Connection_Electric, z_Miele_Connection_Liquid Detergent, z_Miele_Connection_Connection_Modul, z_Miele_Connection_Water_OUT
Pset_BuildingElementProxyCommon - sets with these values: 2
